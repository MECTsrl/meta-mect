FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://memtool_profile \
		"


