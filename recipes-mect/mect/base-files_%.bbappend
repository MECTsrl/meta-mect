FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://share/dot.bashrc \
		"


