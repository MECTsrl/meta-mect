SRC_URI += "file://uboot-LVDS-and-DualDispaly.patch "
