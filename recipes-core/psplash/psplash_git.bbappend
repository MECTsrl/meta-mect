FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-psplash-Change-colors-for-the-Variscite-Yocto-logo.patch \
	    file://0002-psplash-Change-colors-for-the-MECT-Yocto-logo.patch \
	    file://psplash-poky-img.h \
            file://psplash-init \
	   "
# SPLASH_IMAGES = "file://psplash-default.h;outsuffic=default"



